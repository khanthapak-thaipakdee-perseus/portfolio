# Keil uVision project gpio_input_interrupt.uvprojx, settings and files
target gpio_input_interrupt debug (6210000::V6.21::ARMCLANG)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: gpio_input_interrupt.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, MCUXPRESSO_SDK, PRINTF_FLOAT_ENABLE=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group source
    ./: main.c ELEC422.C ELEC422.h
  group board
    ./: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ./: readme.txt
target gpio_input_interrupt release (6210000::V6.21::ARMCLANG)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.14.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: gpio_input_interrupt.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: .
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
software components: CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Device:CMSIS:MK64F12_header 1.0.0, Device:CMSIS:MK64F12_system 1.0.0, Device:SDK Drivers:adc 2.2.0, Device:SDK Drivers:clock 2.5.1, Device:SDK Drivers:common 2.3.1, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.5.3, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:port 2.2.0, Device:SDK Drivers:smc 2.0.7, Device:SDK Drivers:uart 2.5.1, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:Startup 1.1.0
